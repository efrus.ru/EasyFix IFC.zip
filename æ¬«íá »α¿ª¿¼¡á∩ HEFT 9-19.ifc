Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T13:05:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 13:05:59 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{DAF74DE5-A238-45F9-8A8F-46338B6959DD}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 13:05:59 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 13:05:59 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 13:05:59 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Скоба прижимная HEFT 9-19, Скоба прижимная HEFT:Скоба прижимная HEFT 9-19:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Скоба прижимная HEFT 9-19; EF_Артикул: 1-06151; EF_Масса: 1.64; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Крепление профиля системы HEF к полкам металлических конструкций, толщиной от 9 до 19 мм. ОБЯЗАТЕЛЬНО! Использование парно. При установке на металлоконструкцию скобы соединяются между собой шпильками М10 и производится натяжка. ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Удобный диапазон регулировки • Дополнительная фиксация элемента за счет крепления болтами в боковые отверстия; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/skoba_prizhimnaya_heft_9_19/; URL: https://efrus.ru
