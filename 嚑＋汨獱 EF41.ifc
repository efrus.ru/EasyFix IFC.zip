Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T15:08:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 15:08:07 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{8198E2A0-44E3-4A0C-BEE9-43FE0E92804D}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 15:08:07 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 15:08:07 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 15:08:07 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: 41, Заглушка:41:460134
In: Уровень 1
Type - Material: EF_Прозрачный, EF_Пластик
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Заглушка EF 41-41D; EF_Артикул: 1-03551; EF_Масса: 0.01; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Для установки в торец монтажного профиля/консоли.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/zaglushka_ef_41_41d/; URL: https://efrus.ru
