Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T08:53:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 08:53:38 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{23FBE4DA-3A24-4E7C-99BB-BE81965E26D4}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 08:53:37 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 08:53:37 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 08:53:37 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: EFP FIX 2-1 - 750 мм, НО EFP FIX 2-1:EFP FIX 2-1 - 750 мм:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь, EF_Прозрачный
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Опора неподвижная комплект EFP FIX 2/1 (750 мм); EF_Артикул: 1-05431; EF_Масса: 12.28; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Используется для монтажа и фиксации трубопроводов различного диаметра, воспринимающего различный диапазон осевых нагрузок • Максимальная нагрузка 16 kN • Диапазон регулировки высоты 30 мм В комплект поставки неподвижных опор не входят хомуты. Данные позиции приобретаются отдельно; URL страницы изделия: https://efrus.ru/catalog/nepodvizhnye_i_skolzyashchie_opory_easyfix/opora_nepodvizhnaya_komplekt_efp_fix_2_1/; URL: https://efrus.ru
