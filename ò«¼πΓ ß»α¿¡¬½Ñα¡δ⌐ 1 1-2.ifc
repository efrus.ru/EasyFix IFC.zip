Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T16:33:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 16:33:40 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{AF04837A-8318-4340-9F09-9922BBE0EB93}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 16:33:40 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 16:33:40 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 16:33:40 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: 1 1/2" 48-53, Хомут спринклерный:1 1/2" 48-53:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Хомут спринклер EF 1 1/2" 48-53; EF_Артикул: 3-04051; EF_Масса: 0.05; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: • Монтаж спринклерных систем ПРЕИМУЩЕСТВА: • Удобное крепление трубы • Надежный и простой узел • Экономичное решение для монтажа систем пожаротушения; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/khomuty/khomut_sprinkler_ef/; URL: https://efrus.ru
