Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T07:34:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 07:34:44 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{C34CA1C1-29AB-4895-A5F0-E0309AFEC342}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 07:34:44 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 07:34:44 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 07:34:44 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Анкер фасадный, Анкер фасадный:Анкер фасадный:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь, EF_Пластик
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Дюбель фасадный R-FF-1-N-10x100 Delta; EF_Артикул: 8-07122; EF_Масса: 0.04; EF_Изготовитель: EASYFIX; EF_Описание: Свойства и преимущества • Применяется при строении и реставрации вентилируемых фасадов • Шуруп имеет 2 участка резьбы: в первой зоне диаметр стержня меньше, а резьба выше, что облегчает вкручивание шурупа, во второй диаметр стержня больше, а резьба ниже, что способствует увеличению распора дюбеля • Продольные рёбра упрощают вхождение рамного дюбеля в отверстие и препятствуют его прокручиванию Применение • Вентилируемые фасады • Фасады (монтаж конструктивных элементов, выполненных из металла или дерева) • Спутниковые антенны • Ворота • Промышленные ворота • Дверные и оконные рамы • Гаражная дверь • Кабельные провода и желоба • Перила; URL страницы изделия: https://efrus.ru/catalog/mekhanicheskie_ankery/r_ff1/dyubel_fasadnyy_r_ff_1_n_10x100_delta/; URL: https://efrus.ru
