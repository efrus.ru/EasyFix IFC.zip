Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T19:21:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 19:21:33 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{3706E608-62A7-450D-9876-3E9C3E7A3E0E}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 19:21:33 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 19:21:33 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 19:21:33 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: EFA L3D/P, Соединитель угловой EFA L3D P:EFA L3D/P:611498
In: Уровень 1
Type - Material: EF_Прозрачный, EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Соединитель угловой 3 стороны EFA L3D/P; EF_Артикул: 1-03651; EF_Масса: 0.42; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Усиленная модификация элемента EFA L3D. Наличие боковых ребер обеспечивает надежную фиксацию профиля в выбранном положении. Базовый 3D соединитель для создания сложных пространственных конструкций, идеален для соединения элементов несущей конструкции фальшпола. [все соединения выполняются при помощи болтов М10*20(25)]; URL: https://efrus.ru
