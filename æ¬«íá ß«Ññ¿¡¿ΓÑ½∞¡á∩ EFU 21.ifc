Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T18:16:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 18:16:49 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{A986132F-70F9-4F2D-9335-E2B644903348}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 18:16:49 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 18:16:49 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 18:16:49 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: EFU 21, Скоба соединительная EFU:EFU 21:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Скоба соединительная EFU 21; EF_Артикул: 1-03111; EF_Масса: 0.18; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Универсальный соединитель. Используется как для соединения профилей между собой в виде крестообразного соединения, так и для крепления к базовому материалу [все соединения выполняются при помощи болтов М10*20(25)]; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/skoba_soedinitelnaya_efu21/; URL: https://efrus.ru
