Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T18:00:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 18:00:23 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{72E83665-4D27-4E24-9DD8-D3866CD1ED33}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 18:00:23 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 18:00:23 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 18:00:23 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: EFA L 210, Скоба подвесная EFA L:EFA L 210:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Скоба подвесная EFA L 210; EF_Артикул: 1-04011; EF_Масса: 0.955; EF_Изготовитель: EASYFIX; EF_Описание: Используется для подвесного крепления лотка шириной до 200 мм; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/skoba_podvesnaya_efa_l210/; URL: https://efrus.ru
