Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T12:49:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 12:49:16 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{AFB65B14-A0A4-480D-971C-2BC7AEAFE4F2}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 12:49:16 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 12:49:16 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 12:49:16 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Пластина шарнира HEFA UT, Пластина шарнира HEFA UT:Пластина шарнира HEFA UT:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Пластина шарнира HEFA UT; EF_Артикул: 1-06121; EF_Масса: 1.27; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Создание шарнирных соединений из металлических усиленных монтажных профилей серии HEF. Соединение под разными углами. Создание опорных рам, укосин, силовых распорок. ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Крепление профиля HEF 80 на прямую к соединителю болтом М12*120. Регулировка на 180 градусов. • Дополнительная фиксация элемента за счет стопорных отгибов • Специальная Z - образная насечка для жесткой фиксации элемента. Шаг регулировки - 5 мм.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/plastina_sharnira_hefa_ut/; URL: https://efrus.ru
