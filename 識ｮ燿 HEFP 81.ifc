Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T11:54:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 11:54:20 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{6883EC23-D2E2-48F4-8537-EC3F08911520}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 11:54:20 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 11:54:20 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 11:54:20 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Опора HEFP 81, Опора HEFP 81:Опора HEFP 81:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Опора HEFP 81; EF_Артикул: 1-06031; EF_Масса: 5.29; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Базовый элемент крепления к материалу основания. Опорный элемент для профиля HEF 80 тяжелой монтажной системы. Крепление к бетону на анкеры диаметром до 12 мм. Установка одиночных стоек, П -образных и 3D рам под оборудование и коммуникации ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Высокие показатели прочности на изгиб • Специальная Z - образная насечка для жесткой фиксации элемента. Шаг регулировки - 5 мм.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/opora_hefp_81/; URL: https://efrus.ru
