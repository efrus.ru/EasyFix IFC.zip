Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T17:53:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 17:53:00 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{30849531-7FF4-4C3D-AB6E-328D6842DB62}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 17:52:59 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 17:53:00 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 17:53:00 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: 200, Скоба П-образная:200:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Скоба прижимная П-образная EF 340/240х200; EF_Артикул: 7-09041; EF_Масса: 0.51; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Используются для крепления профилей к квадратным трубам. Наличие нескольких типоразмеров скоб, позволяет крепить профили к трубам, имеющим размер от 50х50 мм до 200х200 мм.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/skoba_prizhimnaya_p_obraznaya_ef_175_135kh55/; URL: https://efrus.ru
