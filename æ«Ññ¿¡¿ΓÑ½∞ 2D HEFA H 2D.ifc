Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T13:55:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 13:55:37 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{034AAA4A-1B3E-4CFF-BBD6-BF59369FFED7}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 13:55:36 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 13:55:37 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 13:55:37 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Соединитель 2D HEFA H 2D, Соединитель 2D HEFA H 2D:Соединитель 2D HEFA H 2D:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Соединитель 2D HEFA H 2D; EF_Артикул: 1-06211; EF_Масса: 3.59; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Модификация элемента HEFA 2D с боковой отбортовкой для более жесткого крепления профиля при горизонтальном положении. Создание опорных рам, торцевых примыканий профиля друг к другу. Создание перемычек в опорных рамах. ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Высокие показатели прочности на изгиб • Дополнительная фиксация элемента за счет стопорных отгибов • Специальная Z - образная насечка для жесткой фиксации элемента. Шаг регулировки - 5 мм.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/soedinitel_2d_hefa_h_2d/; URL: https://efrus.ru
