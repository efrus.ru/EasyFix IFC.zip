Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T18:23:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 18:23:15 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{A05AFE4F-CEAC-4046-BA75-73CB73A1D472}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 18:23:15 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 18:23:15 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 18:23:15 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: EFA H 2D, Соединитель Т-образный EFA 2D:EFA H 2D:611498
In: Уровень 1
Type - Material: EF_Прозрачный, EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Соединитель Т-образный EFA H 2D; EF_Артикул: 1-03451; EF_Масса: 0.68; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Базовый соединитель для крепление профиля к профилю под углом 90 гр. с помощью закладной гайки EFN. Крепление профиля к базовому материалу при помощи анкеров.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/soedinitel_t_obraznyy_efa_h_2d/; URL: https://efrus.ru
