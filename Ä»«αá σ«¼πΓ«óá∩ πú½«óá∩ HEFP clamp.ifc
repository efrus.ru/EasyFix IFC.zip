Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T11:55:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 11:55:57 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{46018D74-CD1A-4C0E-B267-61E95DBB4FF6}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 11:55:57 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 11:55:57 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 11:55:57 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Опора хомутовая угловая, Опора хомутовая угловая:Опора хомутовая угловая:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Опора хомутовая угловая HEFP clamp; EF_Артикул: 1-06311; EF_Масса: 0.81; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Крепление хомутов тяжелой нагрузки, а так же хомутов серии EFP FIX к профилю монтажной системы серии HEF. Вертикальная фиксация трубопровода. ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Высокие показатели прочности на изгиб • Точное позиционирование на профиле • Болтовое сквозное крепление обеспечивает высокую надежность соединения; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/opora_khomutovaya_uglovaya_hefp_clamp/; URL: https://efrus.ru
