Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T14:57:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 14:57:49 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{DBC9BE6E-4545-4284-9FD9-D1A2A51F936C}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 14:57:49 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 14:57:49 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 14:57:49 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: ST/PVC36, Панель фальшпола:ST/PVC36:611498
In: Уровень 1
Type - Material: EF_Сульфат кальция
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Панель фальшпола EASYFIX S 36 ST/PVC сульфат кальция; EF_Артикул: 1-0404; EF_Масса: 22; EF_Изготовитель: EASYFIX; EF_Описание: Элемент покрытия фальшполов EASYFIX. ST - панель на основе сульфата кальция со стальным листом снизу. ST/PVC - панель на основе сульфата кальция со стальным листом снизу и антистатическим финишным покрытием.; URL страницы изделия: https://efrus.ru/catalog/sistema_promyshlennykh_falshpolov_easyfix/panel_falshpola_easyfix_s_36_st_pvc_sulfat_kaltsiya/; URL: https://efrus.ru
