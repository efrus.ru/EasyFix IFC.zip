Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T17:07:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 17:07:25 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{8CB03EE2-75B6-4804-90A9-05DEA36843B4}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 17:07:25 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 17:07:25 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 17:07:25 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Пластина опорная анкерная EFP M8, Пластина опорная анкерная EFP:Пластина опорная анкерная EFP M8:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Пластина опорная анкерная EFP М8; EF_Артикул: 1-03901; EF_Масса: 0.1; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Пластина для анкерного крепления резьбовой шпильки. Дополнительные отверстия для крепления шурупами.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/plastina_opornaya_ankernaya_efp_m8/; URL: https://efrus.ru
