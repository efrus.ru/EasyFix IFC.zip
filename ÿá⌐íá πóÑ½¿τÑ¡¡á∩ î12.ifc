Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T08:31:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 08:31:31 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{ADBDA897-4EDB-4AF0-AAF8-5FE603C31CA9}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 08:31:30 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 08:31:31 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 08:31:31 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: М12, Шайба увеличенная:М12:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Шайба EF М12 увеличенная; EF_Артикул: 7-04031; EF_Масса: 0.02; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Применяется для соединения элементов монтажной системы.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/metiznaya_produktsiya/shayba_ef_m10_uvelichennaya/; URL: https://efrus.ru
