Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T11:50:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 11:50:47 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{AEBB4FC8-15EA-4A1D-B908-57B611FD881A}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 11:50:46 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 11:50:46 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 11:50:46 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: HEFK 80/1750, Консоль HEFK 80:HEFK 80/1750:611498
In: Уровень 1
Type - Material: EF_Прозрачный, EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Консоль усиленная HEFK 80/1750 ГЦ; EF_Артикул: 1-06272; EF_Масса: 21.53; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Горизонтальный и вертикальный монтаж инженерных систем, ОВиК, ВК, электрики с повышенными требованиями к несущей способности. Создание пространственных рам для оборудования, установка трансформаторов. Создание конструкций фальшпола высотой более 1,5 метров. ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Высокие показатели прочности на изгиб • Возможность комбинации с монтажной системой для средних нагрузок EF; EF_Длина: 1750 mm; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/konsol_usilennaya_hefk_80/; URL: https://efrus.ru
