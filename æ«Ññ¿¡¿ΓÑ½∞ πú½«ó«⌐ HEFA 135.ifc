Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T14:05:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 14:05:50 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{EA21757D-839C-4C9E-B351-B97ABEEE4FB6}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 14:05:50 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 14:05:50 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 14:05:50 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Соединитель угловой HEFA 135, Соединитель угловой HEFA 135:Соединитель угловой HEFA 135:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Соединитель угловой HEFA 135; EF_Артикул: 1-06351; EF_Масса: 1.55; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Угловое соединение металлических усиленных монтажных профилей серии HEF. Соединение под углом 135 градусов. Создание укосин, усиление вертикальных стоек ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Высокие показатели прочности на изгиб • Дополнительная фиксация элемента за счет стопорных отгибов • Специальная Z - образная насечка для жесткой фиксации элемента. Шаг регулировки - 5 мм.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/soedinitel_uglovoy_hefa_135/; URL: https://efrus.ru
