Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T13:15:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 13:15:49 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{EDF4A313-EC6B-42E7-B564-9BAA7F710353}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 13:15:49 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 13:15:49 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 13:15:49 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Скоба соединительная HEFU 81, Скоба соединительная HEFU 81:Скоба соединительная HEFU 81:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Скоба соединительная HEFU 81; EF_Артикул: 1-06161; EF_Масса: 1.81; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Накидное крестообразное соединение металлических усиленных монтажных профилей серии HEF. Соединение под углом 90 градусов. Создание опорных рам. Сборка опорных 3D конструкций. ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Высокие показатели прочности на изгиб • Дополнительная фиксация элемента за счет стопорных отгибов • Специальная Z - образная насечка для жесткой фиксации элемента. Шаг регулировки - 5 мм.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/skoba_soedinitelnaya_hefu_81/; URL: https://efrus.ru
