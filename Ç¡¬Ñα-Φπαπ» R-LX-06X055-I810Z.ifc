Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T07:43:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 07:43:19 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{D96A0D49-7EBC-4480-BEE5-921C45C53194}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 07:43:19 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 07:43:19 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 07:43:19 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: М8/М10 6х55, Анкер-шуруп I:М8/М10 6х55:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Анкер-шуруп R-LX-06X055-I8/10Z; EF_Артикул: 8-014171; EF_Масса: 0.05; EF_Изготовитель: EASYFIX; EF_Описание: Свойства и преимущества • Оперативная установка с использованием отлаженной процедуры: просто просверлите отверстие и установите в него винт • Возможно легко демонтировать при необходимости • Уникальная конструкция с запатентованной формой резьбы обеспечивает высокую производительность при относительно небольшом диаметре отверстия • Отсутствие расширения обеспечивает более низкий риск повреждения материала основания и делает изделия R-LX наилучшим выбором при установке близко к краю и поблизости от других анкеров • Вариант ZF c системой цинковых ламельных покрытий - защитное покрытие Delta Protekt® KL 101 • Высокая прочность крепления в бетоне c трещинами и без трещин • Возможность анкеровки на стандартную или редуцированную глубину (редуцированная глубина с целью предотвращения контакта с арматурой) • Пригодность для сейсмоопасных зон С1 и С2 • Возможность использования в различных условиях благодаря разным видам головок анкера Применение • Сквозной монтаж • Временные крепления • Опалубочные подпорки • Балюстрады и перила • Ограждения и ворота • Стеллажи • Общественные сидения • Строительные леса • Витражные системы • Навесные фасадные системы; URL страницы изделия: https://efrus.ru/catalog/mekhanicheskie_ankery/r_lx/anker_shurup_r_lx_6/; URL: https://efrus.ru
