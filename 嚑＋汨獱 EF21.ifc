Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T15:05:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 15:05:59 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{BB0247AF-61EF-4194-9754-DC15812045B9}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 15:05:58 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 15:05:59 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 15:05:59 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: 21, Заглушка:21:460134
In: Уровень 1
Type - Material: EF_Прозрачный, EF_Пластик
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Заглушка EF 21; EF_Артикул: 1-03811; EF_Масса: 0.01; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Для установки в торец монтажного профиля/консоли.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/zaglushka_ef_21/; URL: https://efrus.ru
