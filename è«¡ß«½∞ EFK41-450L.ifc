Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T16:25:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 16:25:11 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{A29F8EA9-5E43-490A-96E3-71268D7C90D4}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 16:25:11 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 16:25:11 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 16:25:11 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: EFK 41/450L, Консоль EFK41L:EFK 41/450L:611498
In: Уровень 1
Type - Material: EF_Прозрачный, EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Монтажная консоль EFK41/450L; EF_Артикул: 1-02241; EF_Масса: 1.32; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Предназначены для монтажа инженерных систем средних нагрузок на определенном расстоянии от пола, стен и потолочных конструкций зданий и сооружений. Комбинированное использование монтажных консолей с различными элементами системы позволяет получать сложные пространственные конструкции. Допускается использование в виде опор. Универсальность по базовому материалу.; EF_Длина: 450 mm; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/montazhnaya_konsol_efk_41_l/; URL: https://efrus.ru

# IfcOpeningElement: Opening (27)
In: Уровень 1
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Монтажная консоль EFK41/450L; EF_Артикул: 1-02241; EF_Масса: 1.32; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Предназначены для монтажа инженерных систем средних нагрузок на определенном расстоянии от пола, стен и потолочных конструкций зданий и сооружений. Комбинированное использование монтажных консолей с различными элементами системы позволяет получать сложные пространственные конструкции. Допускается использование в виде опор. Универсальность по базовому материалу.; EF_Длина: 450 mm; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/montazhnaya_konsol_efk_41_l/; URL: https://efrus.ru
Name (Консоль EFK41L:EFK 41/450L:611498:...)
1
2
3
4
5
6
7
8
9
10
11
12
13
14
15
16
17
18
19
20
21
22
23
24
25
26
27
