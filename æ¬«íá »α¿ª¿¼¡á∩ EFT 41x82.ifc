Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T18:05:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 18:05:13 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{BDFE5BDA-C7B5-4350-B915-8EA4AB382F3E}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 18:05:12 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 18:05:12 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 18:05:12 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: 41х82, Скоба прижимная EFT:41х82:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь, EF_Прозрачный
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Скоба прижимная EFT 41x82; EF_Артикул: 1-03101; EF_Масса: 0.55; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Предназначены для монтажа монтажного профиля к металлическим балкам без сварки и сверления. Допускается крепление ко всем видам стандартных балок с толщиной полки до 23 мм. ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Простота установки • Эстетичный внешний вид; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/skoba_prizhimnaya_eft_41x82/; URL: https://efrus.ru
