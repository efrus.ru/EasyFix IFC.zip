Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T17:01:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 17:01:56 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{5DD38E10-C6BC-487C-A256-768547BD6EE9}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 17:01:56 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 17:01:56 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 17:01:56 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Опора шарнирная анкерная EFP H 41 T, Опора шарнирная анкерная EFP H 41 T:Опора шарнирная анкерная EFP H 41 T:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь, EF_Прозрачный
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Опора шарнирная анкерная EFP H 41 T; EF_Артикул: 1-03931; EF_Масса: 1.21; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Универсальный шарнирный соединитель для базового материала. Используется для создания наклонных стоек, подпоров, а так же крепления к наклонным поверхностям.; URL: https://efrus.ru
