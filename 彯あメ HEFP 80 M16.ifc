Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T12:53:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 12:53:32 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{3BFA8EE7-8311-468F-8F66-9CC4EC2C0184}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 12:53:32 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 12:53:32 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 12:53:32 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Подвес HEFP 80 M16, Подвес HEFP 80 M16:Подвес HEFP 80 M16:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Подвес HEFP 80 M16; EF_Артикул: 1-06301; EF_Масса: 1.87; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Крепление резьбовой шпильки М16 к профилю серии HEF ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Высокие показатели прочности на изгиб • Болтовое сквозное крепление обеспечивает высокую надежность соединения; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/podves_hefp_80_m16/; URL: https://efrus.ru
