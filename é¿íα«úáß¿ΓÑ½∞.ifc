Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T15:04:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 15:04:07 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{E5C1F5CE-CF8C-4528-A623-C1591D307066}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 15:04:07 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 15:04:07 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 15:04:07 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Виброгаситель резиновый, Виброгаситель:Виброгаситель резиновый:460134
In: Уровень 1
Type - Material: EF_Резина
EASYFIX - EF_Единицы измерения: м.п.; EF_Наименование: Виброгаситель резиновый EF 21-41D; EF_Артикул: 1-035**; EF_Масса: 0.46; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Звукоизоляция для профилей системы EF 21-41D. Возможность изолирования шпильки М10. Рассеивание или полное предотвращение шумов и вибрация, возникающих в воздуховоде.; EF_Длина: 1000 mm; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/vibrogasitel_rezinovyy_ef_21_41d_20m/; URL: https://efrus.ru
