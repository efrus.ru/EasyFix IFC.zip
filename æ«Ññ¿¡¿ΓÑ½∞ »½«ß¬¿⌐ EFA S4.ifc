Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T18:28:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 18:28:55 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{DC84A7F1-322F-4675-A6C2-796478E46470}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 18:28:54 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 18:28:55 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 18:28:55 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: EFA S4, Соединитель плоский EFA S:EFA S4:611498
In: Уровень 1
Type - Material: EF_Прозрачный, EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Соединитель плоский EFA S4; EF_Артикул: 1-03401; EF_Масса: 0.37; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Простые соединители для создания фиксации примыкающих монтажных профилей, не испытывающих высоких нагрузок. [все соединения выполняются при помощи болтов М10*20(25)]; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/soedinitel_ploskiy_efa_s4/; URL: https://efrus.ru
