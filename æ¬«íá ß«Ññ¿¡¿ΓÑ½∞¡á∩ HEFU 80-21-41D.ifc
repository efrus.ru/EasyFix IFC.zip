Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T13:12:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 13:12:20 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{7F19D88F-5518-49E7-9B1C-28B3833D03BD}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 13:12:20 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 13:12:20 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 13:12:20 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Скоба соединительная HEFU 80-21-41D, Скоба соединительная HEFU 80-21-41D:Скоба соединительная HEFU 80-21-41D:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Скоба соединительная HEFU 80-21-41D; EF_Артикул: 1-06331; EF_Масса: 0.31; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Создание соединения профиля системы EF с профилем системы HEF. Крестообразное соединения двух профилей. Комбинация двух систем позволяет использовать материалы более рационально с точки зрения нагрузки.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/skoba_soedinitelnaya_hefu_80_21_41d/; URL: https://efrus.ru
