Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T15:16:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 15:16:58 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{78264539-73B7-4D19-AEC0-2B6C0D9D49E7}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 15:16:58 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 15:16:58 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 15:16:58 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: D-0280, Хомут вентиляционный:D-0280:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь, EF_Резиновый уплотнитель
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Хомут вентиляционный EF 280; EF_Артикул: 3-02101; EF_Масса: 0.41; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: • Монтаж систем вентиляции ПРЕИМУЩЕСТВА: • Удобное крепление систем вентиляции • Возможность крепления за боковые отверстия • Высокие несущие характеристики; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/khomuty/khomut_ventilyatsionnyy_ef/; URL: https://efrus.ru
