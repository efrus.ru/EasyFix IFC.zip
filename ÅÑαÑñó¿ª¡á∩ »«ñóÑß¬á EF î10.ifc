Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T17:05:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 17:05:30 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{641C13FF-0E4A-403A-8985-F39C58CCF9E7}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 17:05:29 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 17:05:30 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 17:05:30 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: М10, Передвижная подвеска EF:М10:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Передвижная подвеска EF М10; EF_Артикул: 1-03851; EF_Масса: 0.13; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Для горизонтального монтажа трубопроводов на маятниковых креплениях. Одиночное крепление для трубопроводов и канализационных сетей. Гибкий поворотный эффект (макс. отклонение 15°); URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/peredvizhnaya_podveska_ef_m8/; URL: https://efrus.ru
