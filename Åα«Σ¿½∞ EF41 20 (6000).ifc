Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T17:39:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 17:39:18 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{C808B03B-81FA-4D6C-B529-717B3816ADA3}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 17:39:18 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 17:39:18 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 17:39:18 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: EF 41/20 6м, Профиль EF41 20:EF 41/20 6м:611498
In: Уровень 1
Type - Material: EF_Прозрачный, EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: м.п.; EF_Наименование: Профиль монтажный EF 41/20 (6000); EF_Артикул: 1-01021-6; EF_Масса: 2.02; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Предназначены для монтажа инженерных систем средних нагрузок на определенном расстоянии от пола, стен и потолочных конструкций зданий и сооружений. Комбинированное использование монтажных консолей с различными элементами системы позволяет получать сложные пространственные конструкции. Допускается использование в виде опор. Универсальность по базовому материалу.; EF_Длина: 1000 mm; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/profil_montazhnyy_ef_41_20/; URL: https://efrus.ru

# IfcOpeningElement: Opening (60)
In: Уровень 1
EASYFIX - EF_Единицы измерения: м.п.; EF_Наименование: Профиль монтажный EF 41/20 (6000); EF_Артикул: 1-01021-6; EF_Масса: 2.02; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Предназначены для монтажа инженерных систем средних нагрузок на определенном расстоянии от пола, стен и потолочных конструкций зданий и сооружений. Комбинированное использование монтажных консолей с различными элементами системы позволяет получать сложные пространственные конструкции. Допускается использование в виде опор. Универсальность по базовому материалу.; EF_Длина: 1000 mm; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/profil_montazhnyy_ef_41_20/; URL: https://efrus.ru
Name (Профиль EF41 20:EF 41/20 6м:611498:...)
1
2
3
4
5
6
7
8
9
10
11
12
13
14
15
16
17
18
19
20
21
22
23
24
25
26
27
28
29
30
31
32
33
34
35
36
37
38
39
40
41
42
43
44
45
46
47
48
49
50
51
52
53
54
55
56
57
58
59
60
