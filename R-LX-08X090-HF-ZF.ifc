Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-31T09:26:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 09:26:22 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{176C6366-8B80-4B01-9408-6E203BF0D53A}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 09:26:21 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 09:26:22 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 09:26:22 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: М8х90, Анкер шуруп HF:М8х90:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
Pset_BuildingElementProxyCommon - Reference: М8х90
Pset_ManufacturerTypeInformation - Manufacturer: EASYFIX
