Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T10:39:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 10:39:04 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{41213DD9-D1B3-4E37-9A1A-E3537958F147}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 10:39:03 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 10:39:03 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 10:39:03 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Опора скользящая подвесная EFP SLIDE 75/10/12, Опора скользящая EFP SLIDE:Опора скользящая подвесная EFP SLIDE 75/10/12:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Опора скользящая подвесная EFP SLIDE 75/10/12; EF_Артикул: 1-05831; EF_Масса: 1.27; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Скользящие опоры EASYFIX для компенсации линейных температурных расширений трубопроводов • Диапазон хода 160 мм • Крепления к различным базовым материалам; URL страницы изделия: https://efrus.ru/catalog/nepodvizhnye_i_skolzyashchie_opory_easyfix/skolzyashchie_opory_efp_slide/opora_skolzyashchaya_podvesnaya_efp_slide_75_10_12/; URL: https://efrus.ru
