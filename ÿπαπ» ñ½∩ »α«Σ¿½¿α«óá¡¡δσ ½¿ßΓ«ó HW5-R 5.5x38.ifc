Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T08:25:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 08:25:37 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{DE446068-8B42-49F7-BFFF-B8DD4B0C48DD}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 08:25:36 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 08:25:37 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 08:25:37 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: 5.5х38, Саморез HW5-R:5.5х38:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Шуруп для профилированных листов HW5-R 5.5x38; EF_Артикул: 7-07021; EF_Масса: 0.01; EF_Изготовитель: HARPOON; EF_Описание: Свойства и преимущества • Закаленная углеродистая сталь SAE 1022, антикоррозийное покрытие RUSPERT ® TYPE II • Пресс-шайба d = 15 мм • Увеличенная до 5 мм высота головки самосверлящего шурупа для лучшего удержания в бите; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/metiznaya_produktsiya/shurup_dlya_profilirovannykh_listov_hw5_r/; URL: https://efrus.ru
