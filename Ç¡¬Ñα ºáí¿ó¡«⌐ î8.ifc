Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T07:32:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 07:32:00 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{6333A535-27BD-427D-98B6-BDFAD37B20EE}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 07:32:00 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 07:32:00 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 07:32:00 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: М8, Анкер забивной:М8:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Анкер забивной R-DCL-08; EF_Артикул: 8-09161; EF_Масса: 0.01; EF_Изготовитель: EASYFIX; EF_Описание: Свойства и преимущества • Высокая прочность крепления в бетоне с трещинами и без трещин (сертификат ЕТА) • Изделие рекомендовано для применения с целью обеспечения огнеупорных свойств • Материал из нержавеющей стали, обеспечивающий высокую стойкость к коррозии • Легкий монтаж с помощью молотка • Анкерная втулка с внутренней резьбой обеспечивает легкую установку и распор Применение • Системы трубопроводов • Вентиляционные системы • Спринклерная система пожаротушения • Кабельные желоба и провода • Подвесные потолки; URL страницы изделия: https://efrus.ru/catalog/mekhanicheskie_ankery/r_dcl/anker_zabivnoy_r_dca_l_m10/; URL: https://efrus.ru
