Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T14:37:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 14:37:29 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{B1DCF109-2CA0-4C75-BE17-3D053310EB5E}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 14:37:29 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 14:37:29 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 14:37:29 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Шайба подкладочная, Шайба подкладочная:Шайба подкладочная:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Шайба подкладочная 30x6; EF_Артикул: 1-06171; EF_Масса: 0.03; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Шайба подкладочная. Применяется для выравнивания плоскости в местах соединения монтажной системы серии HEF с монтажной системой серии EF. Выравнивание плоскости профиля HEF с плоскостью накладных соединителей системы HEF ПРЕИМУЩЕСТВА: • Выравнивание плоскости для точного позиционирования монтажного профиля EF • Высокие показатели прочности на изгиб • Дополнительная фиксация элемента за счет стопорных отгибов; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/shayba_podkladochnaya_30_6_gts/; URL: https://efrus.ru
