Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T14:30:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 14:30:53 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{57ECCD16-398B-4074-8638-3AF4D5067910}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 14:30:53 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 14:30:53 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 14:30:53 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Соединитель угловой HEFA T, Соединитель угловой HEFA T:Соединитель угловой HEFA T:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Соединитель угловой HEFA T; EF_Артикул: 1-06111; EF_Масса: 1.7; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Угловое соединение металлических усиленных монтажных профилей серии HEF. Соединение под углом 90 градусов. Создание опорных рам, торцевых примыканий профиля друг к другу, изготовление одинарных T-образных стоек. ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Высокие показатели прочности на изгиб • Дополнительная фиксация элемента за счет стопорных отгибов • Специальная Z - образная насечка для жесткой фиксации элемента. Шаг регулировки - 5 мм.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/soedinitel_uglovoy_hefa_t/; URL: https://efrus.ru
