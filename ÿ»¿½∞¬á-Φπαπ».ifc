Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T08:35:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 08:35:26 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{EE4246B2-6980-4A8F-9222-08EA2765B253}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 08:35:26 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 08:35:26 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 08:35:26 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Шуруп-шпилька, Шпилька-шуруп:Шуруп-шпилька:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Шпилька-шуруп сантехническая 10х100; EF_Артикул: 7-08091; EF_Масса: 0.03; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Шпилька-шуруп предназначена для монтажа к стене или перекрытию. Шестигранник между шпилькой и шурупом для точной регулировки. Крепления для невысоких нагрузок. Использовать с "Дюбель 12х60 нейлон".; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/metiznaya_produktsiya/shpilka_shurup_santekhnicheskaya/; URL: https://efrus.ru
