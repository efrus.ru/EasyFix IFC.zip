Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T15:04:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 15:04:56 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{068CD841-75F4-43E4-BB10-59080BDF82FF}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 15:04:56 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 15:04:56 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 15:04:56 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Панель фальшпола EASYFIX 600*600 сталь перфорированная PVC, Панель фальшпола перфорированная:Панель фальшпола EASYFIX 600*600 сталь перфорированная PVC:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Панель фальшпола EASYFIX 600*600 сталь перфорированная PVC; EF_Артикул: 1-0410; EF_Масса: 12.8; EF_Изготовитель: EASYFIX; EF_Описание: Элемент покрытия фальшполов EASYFIX. панель предназначена для осуществления свободного воздухообмена между подпольным пространством и помещением над ним. Материал - стальной каркас с антистатическим финишным покрытием.; URL страницы изделия: https://efrus.ru/catalog/sistema_promyshlennykh_falshpolov_easyfix/panel_falshpola_easyfix_600_600_stal_perforirovannaya_pvc/; URL: https://efrus.ru
