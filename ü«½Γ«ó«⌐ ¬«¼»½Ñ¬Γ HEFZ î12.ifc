Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T11:38:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 11:38:05 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{97AD5C45-DB71-437E-8698-312D6A82C991}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 11:38:05 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 11:38:05 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 11:38:05 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: M12, Болтовой комплект HEFZ:M12:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Болтовой комплект HEFZ M12; EF_Артикул: 1-06391; EF_Масса: 0.081; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Комплект предназначен для крепления соединителей и профилей монтажной системы HEF в условиях невозможности сквозного соединения. Болтовой комплект HEFZ M12 предназначен для крепления через округлые отверстия соединителей, Болтовой комплект HEFZ Z5 M12 для крепления через зубчатые отверстия соединителей.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/boltovoy_komplekt_hefz_m12/; URL: https://efrus.ru
