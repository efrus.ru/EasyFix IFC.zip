Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T07:36:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 07:36:04 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{60C5BD4E-E4C6-4B5B-B810-9224AFB1EC3F}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 07:36:04 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 07:36:04 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 07:36:04 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: BIT-200, Анкер химический:BIT-200:611498
In: Уровень 1
Type - Material: EF_Химический состав
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Химический анкер EASYFIX BIT-200 (420 мл); EF_Артикул: 2-0106; EF_Масса: 0.8; EF_Изготовитель: EASYFIX; EF_Описание: Назначение и область применения Специально разработан для осуществления анкерных креплений высокой категории надежности в сжатую и растянутую зону бетона под высокие динамические и сейсмические эксплуатационные нагрузки (в том числе шоковые и критические воздействия). Отсутствие усадочной деформации создаёт условия для монтажа арматуры больших диаметров, а также закладных деталей с большими кольцевыми зазорами. Выдерживает высокие рабочие температуры, что позволяет производить сварку установленных арматурных прутков. Рекомендуется для применения в транспортном строительстве для монтажа барьерных ограждений и шумозащитных экранов, в несущих конструкциях, подверженных динамическим воздействиям, и в зонах высокой сейсмической активности (допуски категории С1 и С2). Преимущества • в качестве анкера допускается применять любые резьбовые шпильки, арматурные прутки, анкерные и фундаментные болты (ГОСТ 24379.1-2012, тип 5 / СНиП 2.09.03) • без ограничений допускается применение в основаниях из различного вида кирпича, ячеистого бетона и пустотелых материалов • не создает напряжения в материале основания • возможно приложение высоких нагрузок при малых расстояниях между осями креплений и от края конструкции • применяется для установки арматуры периодического профиля и организации арматурных выпусков в монолитном железобетоне (СНиП 52-01-2003) • устойчив к воздействию высоких температур (до +120°С) • применяется во влажных отверстиях, водонасыщенном бетоне и под водой • высокая устойчивость к агрессивным средам, кислотам, щелочам, нефтепродуктам и сточным водам нефтепереработки • не имеет запаха, рекомендуется для внутренних работ и в закрытых помещениях • не огнеопасен, высокая точка воспламенения • экологически нейтральный продукт • гарантийный срок эксплуатации 50 лет (регламент ЕТА ЕС); URL страницы изделия: https://efrus.ru/catalog/khimicheskie_ankery/khimicheskiy_anker_easyfix_bit_200_420_ml/; URL: https://efrus.ru
