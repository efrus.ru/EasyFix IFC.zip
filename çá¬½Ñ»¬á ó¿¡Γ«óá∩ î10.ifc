Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T08:24:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 08:24:17 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{E373E377-771C-4F36-956A-B5A89FEF7E2E}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 08:24:17 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 08:24:17 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 08:24:17 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: М10, Заклепка винтовая:М10:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Заклепка гаечная стальная, М10 CN1-СB-S цилиндрическая с насечкой, цилиндрический борт; EF_Артикул: 7-06341; EF_Масса: 0.01; EF_Изготовитель: HARPOON; EF_Описание: ПРИМЕНЕНИЕ: • Простой и быстрый монтаж. • Возможность установки как в готовые изделия, так и отдель- ные детали, при этом риск повреждения поверхностей практи- чески полностью исключен. • Расклепка заклепок гаечного типа возможна с одной стороны; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/metiznaya_produktsiya/zaklepka_gaechnaya_stalnaya_m10_cn1_cb_s_tsilindricheskaya_s_nasechkoy_tsilindricheskiy_bort/; URL: https://efrus.ru
