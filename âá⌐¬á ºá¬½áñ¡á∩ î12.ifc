Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T08:38:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 08:38:09 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{680079AD-B0DC-4D4C-B177-FB6F5336F496}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 08:38:09 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 08:38:09 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 08:38:09 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: М12, Гайка закладная:М12:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Гайка закладная EFN 12; EF_Артикул: 1-03181; EF_Масса: 0.04; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ Универсальный гайка. Используется как закладной элемент крепления профилей друг к другу при помощи соединительных элементов. Крепление одиночных хомутов к открытой части профиля [все соединения выполняются при помощи болтов М10*20(25)]; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/gayka_zakladnaya_efn_6/; URL: https://efrus.ru
