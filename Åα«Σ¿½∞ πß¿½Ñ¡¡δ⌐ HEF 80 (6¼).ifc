Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T12:57:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 12:57:47 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{04E568C0-260C-4CE1-BB6D-73DE021DD8B4}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 12:57:47 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 12:57:47 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 12:57:47 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Профиль усиленный HEF 80 (6 м), Профиль усиленный HEF 80:Профиль усиленный HEF 80 (6 м):611498
In: Уровень 1
Type - Material: EF_Прозрачный, EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: м.п.; EF_Наименование: Профиль усиленный HEF 80 (6м) ГЦ; EF_Артикул: 1-06232; EF_Масса: 10.18; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Горизонтальный и вертикальный монтаж инженерных систем, ОВиК, ВК, электрики с повышенными требованиями к несущей способности. Создание пространственных рам для оборудования, установка трансформаторов. Создание конструкций фальшпола высотой более 1,5 метров. ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Высокие показатели прочности на изгиб • Возможность комбинации с монтажной системой для средних нагрузок EF; EF_Длина: 1000 mm; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/profil_usilennyy_hef_80_gts/; URL: https://efrus.ru
