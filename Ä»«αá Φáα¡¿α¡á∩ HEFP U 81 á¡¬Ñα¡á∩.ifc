Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T12:01:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 12:01:15 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{D3DD0C7B-647B-4AD8-8443-71C92C2C666F}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 12:01:14 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 12:01:15 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 12:01:15 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: HEFP 81 U анкерная, Опора шарнирная HEFP U 81:HEFP 81 U анкерная:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Опора шарнирная HEFP U 81 анкерная; EF_Артикул: 1-06191; EF_Масса: 4.57; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Создание шарнирных соединений из металлических усиленных монтажных профилей серии HEF. Соединение под разными углами. Создание опорных рам, укосин, силовых распорок. Жесткая фиксация свободного профиля. ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Высокие показатели прочности на изгиб • Дополнительная фиксация элемента за счет стопорных отгибов • Специальная Z - образная насечка для жесткой фиксации элемента. Шаг регулировки - 5 мм.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/opora_sharnirnaya_hefp_u_81_ankernaya/; URL: https://efrus.ru
