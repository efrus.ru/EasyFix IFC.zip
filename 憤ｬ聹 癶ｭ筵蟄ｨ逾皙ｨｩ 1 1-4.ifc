Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T16:19:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 16:19:09 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{687A218B-8D25-4D01-914E-0A838175F446}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 16:19:08 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 16:19:09 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 16:19:09 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: 1 1/4" (40-45), Хомут сантехнический:1 1/4" (40-45):611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь, EF_Резиновый уплотнитель
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Хомут EASYFIX 1 1/4" (40-45) сантехнический универсальный двойная резьба М8/М10; EF_Артикул: 3-01041; EF_Масса: 0.07; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: • Трубы систем ОВ и ВК • Канализационные трубы • Трубы для газопровода и отопления ПРЕИМУЩЕСТВА: • Двойная соединительная гайка М8/М10 • Качественная сварка • Использование резьбовых шпилек М8/10 в не зависимости от диаметра хомута; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/khomuty/khomut_easyfix_santekhnicheskiy_universalnyy_m8_10/; URL: https://efrus.ru
