Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-29T16:54:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Oct 29 16:54:32 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{6CA1CDDD-209C-49B5-8E8B-B2B1E8E9AED9}\ifc * Database version: 5507 * Database creation date: Sun Oct 29 16:54:32 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Oct 29 16:54:32 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Oct 29 16:54:32 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: EFP MH L, Опора кровельная шарнирная EFP MH:EFP MH L:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь, EF_Резина, EF_Прозрачный
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Опора кровельная шарнирная EFP MH L; EF_Артикул: 1-03791; EF_Масса: 1.44; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Шарнирная опора для установки на кровлю, выполненную из кровельной сендвич-панели. Используется для устройства опорных рам без повреждения материала основания.; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_ef/opora_krovelnaya_sharnirnaya_efp_mh_l/; URL: https://efrus.ru
