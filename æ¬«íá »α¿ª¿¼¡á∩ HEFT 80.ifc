Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-30T13:01:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Альтернативный интерфейс 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 30 13:01:34 2023 * Host: Administrator * Database: C:\Users\PC-49\AppData\Local\Temp\{277660D6-A33B-4D8B-8D4B-454B4AA740EC}\ifc * Database version: 5507 * Database creation date: Mon Oct 30 13:01:34 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 30 13:01:34 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 30 13:01:34 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm

# IfcBuildingElementProxy: Скоба прижимная EFT 80, Скоба прижимная HEFT 80:Скоба прижимная EFT 80:611498
In: Уровень 1
Type - Material: EF_Оцинкованная сталь, EF_Прозрачный
EASYFIX - EF_Единицы измерения: шт.; EF_Наименование: Скоба прижимная HEFT 80; EF_Артикул: 1-06371; EF_Масса: 1.21; EF_Изготовитель: EASYFIX; EF_Описание: ПРИМЕНЕНИЕ: Предназначены для монтажа монтажного профиля HEF к металлическим балкам без сварки и сверления. Допускается крепление ко всем видам стандартных балок с толщиной полки до 30 мм. ПРЕИМУЩЕСТВА: • Отсутствие необходимости сварных работ • Простота установки • Эстетичный внешний вид; URL страницы изделия: https://efrus.ru/catalog/montazhnaya_sistema/sistema_hef/skoba_prizhimnaya_heft_80/; URL: https://efrus.ru
